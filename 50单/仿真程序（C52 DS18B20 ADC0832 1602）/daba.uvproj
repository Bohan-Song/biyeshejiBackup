# Keil uVision project daba.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: daba +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lcd.c main.c ds18b20.c ADC0832.C
