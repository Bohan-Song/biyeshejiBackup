# Keil uVision project F103R8.uvprojx, settings and files
target STM32F103R8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XYD_SmartCar2_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,debug=1
  c misc: --C99
  c include: ..\CMSIS;..\User;..\FwLIB\inc;..\User\API\Delay;..\User\API\SysTick;..\User\API\GPIO;..\User\API\EXTI;..\User\API\USART;..\User\API\LCD;..\User\API\RTC;..\User\API\IR;..\User\API\SR_04;..\User\API\TCRT5000I;..\User\API\motor;..\User\API\APP;..\User\API\led;..\User\API;..\User\API\key;..\User\API\water;..\User\API\bee;..\User\API\moyor.c;..\User\API\timer;..\User\API\uster;..\User\API\sr;..\User\API\TCRT5000I;..\User\API\IR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group FwLIB
    ../FwLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_tim.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group API
    ../User/API/SysTick/: systick.c
    ../User/API/Delay/: delay.c
    ../User/API/key/: key.c
    ../User/API/led/: led.c
    ../User/API/water/: water.c
    ../User/API/bee/: bee.c
    ../User/API/moyor.c/: motor.c
    ../User/API/timer/: timer.c
    ../User/API/sr/: SR.c
    ../User/API/uster/: usart.c
    ../User/API/IR/: ir.c
    ../User/API/TCRT5000I/: TCRT.c
